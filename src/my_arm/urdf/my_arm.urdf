Commit message: test1.0

File: src/my_arm/urdf/my_arm.urdf (robot description, URDF)
Before this commit: robot my_arm, 6 links, 5 joints
Joints:
- joint joint_1: limit lower=-0.2 upper=0.2 effort=0 velocity=0 -> lower=0 upper=0.25 effort=0 velocity=0
